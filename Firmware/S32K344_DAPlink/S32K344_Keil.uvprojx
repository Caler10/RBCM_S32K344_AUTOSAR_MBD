# Keil uVision project S32K344_Keil.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: S32K344:Cortex-M7_0 NXP
  pack: Keil.S32K3xx_DFP.1.0.1
  cpu: IRAM(0x20400000,0x00028000) IRAM2(0x20428000,0x00028000) IROM(0x00400000,0x00400000) IROM2(0x10000000,0x00020000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(SFPU) DSP CLOCK(12000000)
  output: RBCM_Model.elf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x400000 size 0x400000
  memory RVCT5: ROM 0x10000000 size 0x20000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x20400000 size 0x28000
  memory RVCT10: RAM 0x20428000 size 0x28000
